SYSTEMD_AUTO_ENABLE = "enable"

FILESEXTRAPATHS_prepend := "${THISDIR}/wpa-supplicant:"
